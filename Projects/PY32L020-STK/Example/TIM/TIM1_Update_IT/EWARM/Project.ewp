# IAR project Project.ewp, settings and files
configuration Project (ARM, debug)
  General.OGChipSelectEditMenu: PY32L020x5 Puya PY32L020x5
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; PY32L020x5
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Drivers\BSP\PY32L020xx_Start_Kit; ..\..\..\..\..\..\Drivers\CMSIS\Device\PY32L0xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\PY32L020_HAL_Driver\Inc; ..\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: py32l020x5_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/PY32L020xx_Start_Kit
    ../../../../../../Drivers/BSP/PY32L020xx_Start_Kit/: py32l020xx_Start_Kit.c
  group Drivers/CMSIS
    ../Src/: system_py32l020.c
  group Drivers/PY32L020_HAL_Driver
    ../../../../../../Drivers/PY32L020_HAL_Driver/Src/: py32l020_hal.c py32l020_hal_rcc.c py32l020_hal_rcc_ex.c py32l020_hal_gpio.c py32l020_hal_pwr.c py32l020_hal_uart.c py32l020_hal_cortex.c py32l020_hal_crc.c py32l020_hal_exti.c py32l020_hal_tim.c py32l020_hal_tim_ex.c
  group Example/EWARM
    ./: startup_py32l020xx.s
  group Example/User
    ../Src/: main.c py32l020_hal_msp.c py32l020_it.c
